## config/boards/shields/HSVmod/Kconfig.defconfig
```kconfig
if SHIELD_HSVMOD
            
config ZMK_KEYBOARD_NAME
    default "HSVmod"

endif
```
